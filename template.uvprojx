# Keil uVision project template.uvprojx, settings and files
target rtthread-stm32 (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4
  c misc: --gnu
  library: MicroLIB
  memory RVCT4: ROM 0x8001000 size 0xf000
  memory RVCT9: RAM 0x20000800 size 0x4800
